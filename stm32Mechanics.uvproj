# Keil uVision project stm32Mechanics.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32Mechanics +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\source\c;.\source\h;.\CMSIS\Device\ST\STM32F1xx\Include;.\CMSIS\Device\ST\STM32F1xx\Source\Templates
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./source/c/: adc.c afio.c CRC16.c dma.c etr.c exti.c flash.c gpio.c iwdg.c main.c ModbusRTU.c rcc.c tim.c usart.c pt100.c oven.c
  group Startup
    ./CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f100xe.s
  group CMSIS
    ./CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
